# Keil uVision project STM32F0-SX9500.uvproj, settings and files
target STM32F0-SX9500 (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: STM32F0-SX9500 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F0XX
  c include: .\inc;..\..\Utilities\STM32F0-Discovery;..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\ST\STM32F0xx\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group usr
    ./src/: stm32f0xx_it.c sx9500.c main.c system_stm32f0xx.c task.c
  group stm32f0-stdperiphlib
    ../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_exti.c stm32f0xx_syscfg.c stm32f0xx_rcc.c stm32f0xx_misc.c stm32f0xx_i2c.c stm32f0xx_gpio.c stm32f0xx_tim.c
  group stm32f0-discovery
    ../../Utilities/STM32F0-Discovery/: stm32f0_discovery.c
  group startup
    ./startup/: startup_stm32f0xx.s
